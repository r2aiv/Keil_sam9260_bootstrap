# Keil uVision project Bootloader.uvproj, settings and files
target SAM9260_DF_P1056_CS1_BL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AT91SAM9260 Atmel
  cpu: IRAM(0x200000-0x200FFF) IRAM2(0x300000-0x300FFF) IROM(0x100000-0x107FFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: SAM9260_DF_P1056_CS1_BL
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: P1056_CS1
  c misc: --diag_suppress 61,68
  asm define: SIZE_INT_INFO
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0xe00
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300e00 size 0x200
  group Bootloader Code
    ./: SAM9260.s Bootloader.c DFlashHW.c
  group Documentation
    ./: Abstract.txt
target SAM9260_DF_P1056_CS1 - SAMICE (ARM-ADS)
  device: AT91SAM9260 Atmel
  cpu: as above
  output: SAM9260_DF_P1056_CS1_BL
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: P1056_CS1
  c misc: --diag_suppress 61,68
  asm define: SIZE_INT_INFO
  library: MicroLIB
  memory RVCT1: ROM 0x20000000 size 0x2000000
  memory RVCT4: ROM 0x0 size 0xe00
  memory RVCT6: RAM 0x22000000 size 0x2000000
  memory RVCT9: RAM 0x300e00 size 0x200
